# Autodesk Inventor assembly: ВЕНТИЛЬBITZER_3_1Z8
## iProperties
Created: 2011-02
Part Number: ВЕНТИЛЬBITZER_3_1Z8
Document SubType Name: Assembly
Designer: Чернышев Юрий
Author: Чернышев Юрий
