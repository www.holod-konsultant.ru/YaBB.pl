# Autodesk Inventor assembly: HSN7471-75
## iProperties
Created: 2011-02
Part Number: HSN7471-75
Document SubType Name: Assembly
Designer: Чернышев Юрий
Author: Чернышев Юрий
